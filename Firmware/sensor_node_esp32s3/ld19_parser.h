/*
 * ld19_parser.h — LDROBOT LD19 / LD06 / D300 / D500 frame parser (no Arduino dependency)
 *
 * The LD19 streams fixed 47-byte frames at 230400 baud, about 375 per second
 * at the default 10 Hz scan rate (4500 points/s):
 *
 *   byte 0      0x54            header
 *   byte 1      0x2C            "version/length": type 1, 12 points
 *   bytes 2-3   speed           degrees per second, little-endian
 *   bytes 4-5   start angle     hundredths of a degree
 *   bytes 6-41  12 x { uint16 distance_mm, uint8 intensity }
 *   bytes 42-43 end angle       hundredths of a degree
 *   bytes 44-45 timestamp       ms, wraps at 30000
 *   byte 46     CRC-8           polynomial 0x4D over bytes 0..45
 *
 * Per-point angles are interpolated linearly between start and end angle, the
 * way the manufacturer's SDK does it. Angles increase clockwise seen from above
 * and 0 is the LD19's own physical reference; receivers apply a mounting offset.
 *
 * SPDX-License-Identifier: MIT
 */
#ifndef LD19_PARSER_H
#define LD19_PARSER_H

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#define LD19_FRAME_LEN   47u
#define LD19_POINTS      12u
#define LD19_HEADER      0x54u
#define LD19_VERLEN      0x2Cu
#define LD19_FULL_CIRCLE 36000u

struct Ld19Frame {
    uint16_t speed_deg_s;
    uint16_t start_angle_cdeg;
    uint16_t end_angle_cdeg;
    uint16_t timestamp_ms;
    uint16_t dist_mm[LD19_POINTS];      /* 0 = no return                      */
    uint8_t  intensity[LD19_POINTS];
};

/* CRC-8, polynomial 0x4D, init 0, no reflection. Standard LDROBOT table. */
static const uint8_t LD19_CRC_TABLE[256] = {
    0x00, 0x4D, 0x9A, 0xD7, 0x79, 0x34, 0xE3, 0xAE, 0xF2, 0xBF, 0x68, 0x25, 0x8B, 0xC6, 0x11, 0x5C,
    0xA9, 0xE4, 0x33, 0x7E, 0xD0, 0x9D, 0x4A, 0x07, 0x5B, 0x16, 0xC1, 0x8C, 0x22, 0x6F, 0xB8, 0xF5,
    0x1F, 0x52, 0x85, 0xC8, 0x66, 0x2B, 0xFC, 0xB1, 0xED, 0xA0, 0x77, 0x3A, 0x94, 0xD9, 0x0E, 0x43,
    0xB6, 0xFB, 0x2C, 0x61, 0xCF, 0x82, 0x55, 0x18, 0x44, 0x09, 0xDE, 0x93, 0x3D, 0x70, 0xA7, 0xEA,
    0x3E, 0x73, 0xA4, 0xE9, 0x47, 0x0A, 0xDD, 0x90, 0xCC, 0x81, 0x56, 0x1B, 0xB5, 0xF8, 0x2F, 0x62,
    0x97, 0xDA, 0x0D, 0x40, 0xEE, 0xA3, 0x74, 0x39, 0x65, 0x28, 0xFF, 0xB2, 0x1C, 0x51, 0x86, 0xCB,
    0x21, 0x6C, 0xBB, 0xF6, 0x58, 0x15, 0xC2, 0x8F, 0xD3, 0x9E, 0x49, 0x04, 0xAA, 0xE7, 0x30, 0x7D,
    0x88, 0xC5, 0x12, 0x5F, 0xF1, 0xBC, 0x6B, 0x26, 0x7A, 0x37, 0xE0, 0xAD, 0x03, 0x4E, 0x99, 0xD4,
    0x7C, 0x31, 0xE6, 0xAB, 0x05, 0x48, 0x9F, 0xD2, 0x8E, 0xC3, 0x14, 0x59, 0xF7, 0xBA, 0x6D, 0x20,
    0xD5, 0x98, 0x4F, 0x02, 0xAC, 0xE1, 0x36, 0x7B, 0x27, 0x6A, 0xBD, 0xF0, 0x5E, 0x13, 0xC4, 0x89,
    0x63, 0x2E, 0xF9, 0xB4, 0x1A, 0x57, 0x80, 0xCD, 0x91, 0xDC, 0x0B, 0x46, 0xE8, 0xA5, 0x72, 0x3F,
    0xCA, 0x87, 0x50, 0x1D, 0xB3, 0xFE, 0x29, 0x64, 0x38, 0x75, 0xA2, 0xEF, 0x41, 0x0C, 0xDB, 0x96,
    0x42, 0x0F, 0xD8, 0x95, 0x3B, 0x76, 0xA1, 0xEC, 0xB0, 0xFD, 0x2A, 0x67, 0xC9, 0x84, 0x53, 0x1E,
    0xEB, 0xA6, 0x71, 0x3C, 0x92, 0xDF, 0x08, 0x45, 0x19, 0x54, 0x83, 0xCE, 0x60, 0x2D, 0xFA, 0xB7,
    0x5D, 0x10, 0xC7, 0x8A, 0x24, 0x69, 0xBE, 0xF3, 0xAF, 0xE2, 0x35, 0x78, 0xD6, 0x9B, 0x4C, 0x01,
    0xF4, 0xB9, 0x6E, 0x23, 0x8D, 0xC0, 0x17, 0x5A, 0x06, 0x4B, 0x9C, 0xD1, 0x7F, 0x32, 0xE5, 0xA8,
};

static inline uint8_t ld19Crc8(const uint8_t *data, size_t len) {
    uint8_t crc = 0;
    for (size_t i = 0; i < len; i++) crc = LD19_CRC_TABLE[(uint8_t)(crc ^ data[i])];
    return crc;
}

/* Angle of point i (0..11) in hundredths of a degree, handling the 360 wrap. */
static inline uint16_t ld19PointAngleCdeg(uint16_t start_cdeg, uint16_t end_cdeg, unsigned i) {
    uint32_t s = start_cdeg % LD19_FULL_CIRCLE;
    uint32_t e = end_cdeg % LD19_FULL_CIRCLE;
    uint32_t span = (e + LD19_FULL_CIRCLE - s) % LD19_FULL_CIRCLE;
    return (uint16_t)((s + span * i / (LD19_POINTS - 1)) % LD19_FULL_CIRCLE);
}

/* Byte-wise state machine. feed() returns true when `out` holds a CRC-valid frame. */
class Ld19Parser {
public:
    uint32_t frames = 0;
    uint32_t crcErrors = 0;

    bool feed(uint8_t c, Ld19Frame &out) {
        if (_idx == 0) {
            if (c == LD19_HEADER) _buf[_idx++] = c;
            return false;
        }
        if (_idx == 1) {
            if (c == LD19_VERLEN) { _buf[_idx++] = c; }
            else _idx = (c == LD19_HEADER) ? 1 : 0;
            return false;
        }
        _buf[_idx++] = c;
        if (_idx < LD19_FRAME_LEN) return false;
        _idx = 0;
        if (ld19Crc8(_buf, LD19_FRAME_LEN - 1) != _buf[LD19_FRAME_LEN - 1]) {
            crcErrors++;
            return false;
        }
        out.speed_deg_s      = (uint16_t)(_buf[2] | (_buf[3] << 8));
        out.start_angle_cdeg = (uint16_t)(_buf[4] | (_buf[5] << 8));
        for (unsigned i = 0; i < LD19_POINTS; i++) {
            const uint8_t *p = &_buf[6 + i * 3];
            out.dist_mm[i]   = (uint16_t)(p[0] | (p[1] << 8));
            out.intensity[i] = p[2];
        }
        out.end_angle_cdeg = (uint16_t)(_buf[42] | (_buf[43] << 8));
        out.timestamp_ms   = (uint16_t)(_buf[44] | (_buf[45] << 8));
        frames++;
        return true;
    }

    void reset() { _idx = 0; }

private:
    uint8_t _buf[LD19_FRAME_LEN];
    unsigned _idx = 0;
};

#endif /* LD19_PARSER_H */
